FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

KBRANCH_qemuppc64  ?= "standard/qemuppc"

SRCREV_machine_qemuppc64 ?= "403eda4633e9037fb715d0d1e8ae847b2bd0651a"

COMPATIBLE_MACHINE_qemuppc64 = "qemuppc64"
