FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

KBRANCH_qemuppc64  ?= "standard/qemuppc"

SRCREV_machine_qemuppc64 ?= "35de413056b86191963ffe686913da31b978a9b3"

COMPATIBLE_MACHINE_qemuppc64 = "qemuppc64"
